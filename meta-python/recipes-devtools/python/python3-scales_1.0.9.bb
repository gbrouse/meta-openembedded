inherit setuptools3
require python-scales.inc
